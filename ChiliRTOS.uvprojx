# Keil uVision project ChiliRTOS.uvprojx, settings and files
target ChiliRTOS (6180000::V6.18::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 00_BASIC_BLINKY_F411CEU6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Basic_Blinky
    ./: main.c main.h Interrupts.h Interrupts.c
  group README
    ./: README.md
  group STM32F411CEUx_BSP
    ./: Abstract.txt STM32F4_RTOS_BSP.c STM32F4_RTOS_BSP.h
  group LCD_20x4
    ./: LCD_20x4.c LCD_20x4.h
software components: CMSIS:CORE 6.0.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:Startup 2.6.3
